# IAR project Project.ewp, settings and files
configuration STM32L496G-Discovery_Azure (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L496xx; USE_HAL_DRIVER; BOOTLOADER; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; DONT_USE_UPLOADTOBLOB; AZURE; HSM_TYPE_X509; HSM_TYPE_SAS_TOKEN; USE_PROV_MODULE; EINVAL=22; ENOMEM=12; USE_PROV_MODULE; STRINGS_C_SPRINTF_BUFFER_SIZE=512; USE_C2C_RTOS; HAS_RTOS; MANUAL_SIM_SELECTION; USE_MODEM_BG96; USE_C2C; PARTIAL_HEAP_SIZE=60000
  ICCARM.CCDiagSuppress: Pa084,Pe177,Pe181
  ICCARM.CCIncludePath2: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/BSP/STM32L496G-Discovery; ../Inc; ../../../../../../Middlewares/ST/STM32_Connect_Library/Includes; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ..\..\..\BootLoader_OSC\2_Images_SECoreBin\Inc; ..\..\..\BootLoader_OSC\2_Images_SBSFU\SBSFU\App; ..\..\..\BootLoader_OSC\Linker_Common\EWARM; ../../../../../Misc_Utils/Inc; ../../../../../../Utilities/Time; ../../../../../../Utilities/CLD_utils/http_lib; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/samples/STM32Cube_sample; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/DICE; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT/RIoTCrypt/include; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/pal/generic; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson; ../../../../../../Middlewares/Third_Party/mbedTLS/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/AT_Service/Core/Inc; ../../../../../../Drivers/BSP/Modems/UG96_STMOD+/AT_modem_ug96/Inc; ../../../../../../Drivers/BSP/Modems/BG96_STMOD+/AT_modem_bg96/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Radio_Service/Cellular/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Com/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Data_Cache/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Interface/IPC/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Nifman/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Porting/LwIP_Porting/PPPosif/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Radio_Management/Inc; ../Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Error_Handler/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Trace_Interface/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Stack_Analysis/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Cellular_Init/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Cmd/Inc; ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Cellular_Runtime/Inc; ../../../BootLoader_OSC/Linker_Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  OBJCOPY.OOCOutputFile: STM32L496G-Discovery_Azure.bin
  postbuild: cmd /C  "cmd /C ..\..\..\BootLoader_OSC\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "$TARGET_DIR$\$CONFIG_NAME$.bin" 1 bigelf"
  ILINK.IlinkOutputFile: STM32L496G-Discovery.out
  ILINK.IlinkIcfFile: stm32l496xx_flash_for_sfu.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\..\BootLoader_OSC\Linker_Common\EWARM\
  ILINK.IlinkAdditionalLibs: ..\..\..\BootLoader_OSC\2_Images_SBSFU\EWARM\se_interface_appli.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Azure
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters/: hsm_client_riot_STM32Cube.c hsm_client_tpm_STM32Cube.c
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: platform_STM32Cube.c socketio_mbed.c tcpsocketconnection_c_STM32Cube.c threadapi_STM32Cube.c tickcounter_STM32Cube.c tlsio_mbedtls.c
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/samples/STM32Cube_sample/: azure_sha1.c azure_version.c AzureXcubeSample.c
  group Application/User
    ../Src/: main.c stm32l4xx_it.c mbedtls_entropy.c stm32l4xx_hal_timebase_tim.c board_interrupts.c usart.c stm32l4xx_hal_msp.c flash_l4.c net_conf.c
  group Application/Utils
    ../../../../../Misc_Utils/Src/: cloud.c iot_flash_config.c rfu.c
    ../Src/: set_credentials.c
    ../../../../../../Utilities/CLD_utils/http_lib/: http_lib.c
  group Application/Time
    ../../../../../../Utilities/Time/: STM32CubeRTCInterface.c timingSystem.c timedate.c
  group Application/EWARM
    ./: startup_stm32l496xx.s
  group Doc
    ../: readme.txt
  group BootLoader
    ../: bootloader_readme.txt
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_can.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Drivers/BSP/UG96_STMOD+/at_modem_ug96
    ../../../../../../Drivers/BSP/Modems/UG96_STMOD+/AT_modem_ug96/Src/: at_custom_modem_api_ug96.c at_custom_modem_signalling_ug96.c at_custom_modem_socket_ug96.c at_custom_modem_specific_ug96.c sysctrl_specific_ug96.c
  group Drivers/BSP/BG96_STMOD+/at_modem_bg96
    ../../../../../../Drivers/BSP/Modems/BG96_STMOD+/AT_modem_bg96/Src/: at_custom_modem_api_bg96.c at_custom_modem_signalling_bg96.c at_custom_modem_socket_bg96.c at_custom_modem_specific_bg96.c sysctrl_specific_bg96.c
  group Drivers/BSP/STM32L496G-Discovery
    ../../../../../../Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: azure_base64.c base32.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c http_proxy_io.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_token.c string_tokenizer.c strings.c urlencode.c usha.c vector.c ws_url.c xio.c xlogging.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: iothub_client_authorization.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_retry_control.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c iothub_transport_ll_private.c
  group Middlewares/Third_Party/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
  group Middlewares/Third_Party/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
  group Middlewares/Third_Party/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/src/: iothub_auth_client.c iothub_security_factory.c prov_auth_client.c prov_device_ll_client.c prov_security_factory.c prov_transport_mqtt_client.c prov_transport_mqtt_common.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters/: hsm_client_data.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/DICE
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/DICE/: DiceSha256.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/RIoT
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT/RIoTCrypt/: RiotAes128.c RiotBase64.c RiotCrypt.c RiotDerEnc.c RiotEcc.c RiotHmac.c RiotKdf.c RiotSha256.c RiotX509Bldr.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/ST/STM32_Connect_Library/core
    ../../../../../../Middlewares/ST/STM32_Connect_Library/core/: net_address.c net_core.c net_os.c net_socket.c net_class_extension.c
  group Middlewares/ST/STM32_Connect_Library/services
    ../../../../../../Middlewares/ST/STM32_Connect_Library/services/: net_mbedtls.c
  group Middlewares/ST/STM32_Connect_Library/netif
    ../../../../../../Middlewares/ST/STM32_Connect_Library/netif/cellular_if/: net_cellular.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Service/AT_Service
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/AT_Service/Core/Src/: at_core.c at_datapack.c at_modem_api.c at_modem_common.c at_modem_signalling.c at_modem_socket.c at_parser.c at_util.c sysctrl.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Radio_Service/Cellular
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Service/Radio_Service/Cellular/Src/: cellular_service.c cellular_service_os.c cellular_service_task.c cellular_service_cmd.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Com
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Com/Src/: com_sockets.c com_sockets_err_compat.c com_sockets_ip_modem.c com_sockets_lwip_mcu.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Data_Cache
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Data_Cache/Src/: dc_common.c dc_control.c dc_time.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Nifman
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Nifman/Src/: nifman.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Radio_Mngt
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Radio_Management/Src/: radio_mngt.c
  group Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Cellular_init
    ../../../../../../Middlewares/ST/STM32_Cellular/Core/Cellular_Api/Cellular_Init/Src/: cellular_init.c
  group Middlewares/ST/STM32_Cellular/Interface/IPC
    ../../../../../../Middlewares/ST/STM32_Cellular/Interface/IPC/Src/: ipc_common.c ipc_rxfifo.c ipc_uart.c
  group Middlewares/ST/STM32_Cellular/Porting/PPPosif
    ../../../../../../Middlewares/ST/STM32_Cellular/Porting/LwIP_Porting/PPPosif/Src/: ppposif.c ppposif_client.c ppposif_ipc.c
  group Middlewares/ST/STM32_Cellular/Utilities/Misc/Trace_Interface
    ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Trace_Interface/Src/: trace_interface.c
  group Middlewares/ST/STM32_Cellular/Utilities/Misc/Error_Handler
    ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Error_Handler/Src/: error_handler.c
  group Middlewares/ST/STM32_Cellular/Utilities/Misc/Stack_Analysis
    ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Stack_Analysis/Src/: stack_analysis.c
  group Middlewares/ST/STM32_Cellular/Utilities/Misc/Cmd
    ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Cmd/Src/: cmd.c
    ../../../../../../Middlewares/ST/STM32_Cellular/Utilities/Misc/Cellular_Runtime/Src/: cellular_runtime_custom.c cellular_runtime_standard.c
