# Keil uVision project Project.uvprojx, settings and files
target STM32F413H-Discovery_Azure (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F413H-Discovery_Azure
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  AfterMake: ..\..\..\Bootloader_OSC\2_Images_SECoreBin\MDK-ARM\postbuild.bat . #L $L@L.bin 1 bigelf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,BOOTLOADER,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,ENABLE_IOT_INFO,ENABLE_IOT_ERROR,ENABLE_IOT_WARNING,DONT_USE_UPLOADTOBLOB,AZURE,USE_MBED_TLS,HSM_TYPE_X509,HSM_TYPE_SAS_TOKEN,USE_PROV_MODULE,EINVAL=22,ENOMEM=12,USE_PROV_MODULE,STRINGS_C_SPRINTF_BUFFER_SIZE=512,STM32F413xx,USE_WIFI
  c misc: --gnu  --diag_suppress 177 --diag_suppress 1295
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSPv2/STM32F413H-Discovery;../../../../../../Drivers/BSPv2/Components/Common;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Connect_Library/Includes;../../../BootLoader_OSC/2_Images_SECoreBin/Inc;../../../BootLoader_OSC/2_Images_SBSFU/SBSFU/App;../../../BootLoader_OSC/Linker_Common;../../../BootLoader_OSC/Linker_Common/MDK-ARM;../../../../../Misc_Utils/Inc;../../../../../../Utilities/Time;../../../../../../Utilities/CLD_utils/http_lib;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/samples/STM32Cube_sample;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/DICE;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT/RIoTCrypt/include;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/pal/generic;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/inc;../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Drivers/BSPv2/Components/es_wifi
  library: MicroLIB
  scatter file: .\STM32F413H_Discovery.sct
  group Application/Azure
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters/: hsm_client_riot_STM32Cube.c hsm_client_tpm_STM32Cube.c
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: platform_STM32Cube.c socketio_mbed.c tcpsocketconnection_c_STM32Cube.c threadapi_STM32Cube.c tickcounter_STM32Cube.c tlsio_mbedtls.c
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/samples/STM32Cube_sample/: azure_sha1.c azure_version.c AzureXcubeSample.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c mbedtls_entropy.c stm32f4xx_hal_msp.c flash_f4.c net_conf.c
  group Application/Utils
    ../../../../../Misc_Utils/Src/: cloud.c iot_flash_config.c rfu.c
    ../Src/: set_credentials.c
    ../../../../../../Utilities/CLD_utils/http_lib/: http_lib.c
  group Application/Time
    ../../../../../../Utilities/Time/: STM32CubeRTCInterface.c timingSystem.c timedate.c
  group Application/MDK-ARM
    ./: startup_stm32f413xx.s
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_ll_fsmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../../Drivers/BSPv2/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/STM32F413H-Discovery
    ../../../../../../Drivers/BSPv2/STM32F413H-Discovery/: stm32f413h_discovery.c stm32f413h_discovery_bus.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: azure_base64.c base32.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c http_proxy_io.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_token.c string_tokenizer.c strings.c urlencode.c usha.c vector.c ws_url.c xio.c xlogging.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: iothub_client_authorization.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_retry_control.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c iothub_transport_ll_private.c
  group Middlewares/Third_Party/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
  group Middlewares/Third_Party/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
  group Middlewares/Third_Party/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/src/: iothub_auth_client.c iothub_security_factory.c prov_auth_client.c prov_device_ll_client.c prov_security_factory.c prov_transport_mqtt_client.c prov_transport_mqtt_common.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters/: hsm_client_data.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/DICE
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/DICE/: DiceSha256.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/RIoT
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT/RIoTCrypt/: RiotAes128.c RiotBase64.c RiotCrypt.c RiotDerEnc.c RiotEcc.c RiotHmac.c RiotKdf.c RiotSha256.c RiotX509Bldr.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/ST/STM32_Connect_Library/core
    ../../../../../../Middlewares/ST/STM32_Connect_Library/core/: net_address.c net_core.c net_os.c net_socket.c net_class_extension.c
  group Middlewares/ST/STM32_Connect_Library/services
    ../../../../../../Middlewares/ST/STM32_Connect_Library/services/: net_mbedtls.c
  group Middlewares/ST/STM32_Connect_Library/netif
    ../../../../../../Middlewares/ST/STM32_Connect_Library/netif/wifi_if/es_wifi/: net_es_wifi.c
  group BootLoader
    ../: bootloader_readme.txt
software components: CMSIS:CORE 4.3.0
