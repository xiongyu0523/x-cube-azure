# Keil uVision project Project.uvprojx, settings and files
target STM32F413H_DISCOVERY_2_Images_SECoreBin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F413ZHTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x817FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F413xx,USE_HAL_DRIVER,USE_STM32F413H_DISCOVERY,MBEDTLS_CONFIG_FILE=<se_mbedtls_config.h>
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F413H-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include/mbedtls;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: STM32F413H_DISCOVERY_2_Images_SECoreBin\SECoreBin.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_crc.c
  group Application/User
    ../Src/: se_low_level.c se_crypto_bootloader.c
  group Application/MDK-ARM
    ./: se_key.s data_init.c startup_stm32f413xx.s
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_startup.c se_utils.c se_stack_smuggler_ARM.s se_bootinfo.c se_fwimg.c se_user_application.c se_exception.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c bignum.c camellia.c cipher.c cipher_wrap.c ecdsa.c ecp.c ecp_curves.c gcm.c hmac_drbg.c md.c md_wrap.c platform.c platform_util.c sha256.c
software components: CMSIS:CORE 4.3.0
