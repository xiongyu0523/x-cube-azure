# IAR project Project.ewp, settings and files
configuration STM32F769I-Discovery_Azure (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; BOOTLOADER; STM32F769xx; USE_STM32F769I_DISCO; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; ENABLE_IOT_INFO; ENABLE_IOT_ERROR; ENABLE_IOT_WARNING; DONT_USE_UPLOADTOBLOB; AZURE; HSM_TYPE_X509; HSM_TYPE_SAS_TOKEN; USE_PROV_MODULE; EINVAL=22; ENOMEM=12; USE_PROV_MODULE; STRINGS_C_SPRINTF_BUFFER_SIZE=512; HAS_RTOS; USE_LWIP
  ICCARM.CCDiagSuppress: Pa084,Pe177,Pe181
  ICCARM.CCIncludePath2: ../Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\ST\STM32_Secure_Engine\Core; ../../../../../../Middlewares/ST/STM32_Connect_Library/Includes; ..\..\..\BootLoader_OSC\2_Images_SECoreBin\Inc; ..\..\..\BootLoader_OSC\2_Images_SBSFU\SBSFU\App; ..\..\..\BootLoader_OSC\Linker_Common\EWARM; ../../../../../Misc_Utils/Inc; ../../../../../../Utilities/Time; ../../../../../../Utilities/CLD_utils/http_lib; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/samples/STM32Cube_sample; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/DICE; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT/RIoTCrypt/include; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/pal/generic; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/inc; ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson; ../../../../../../Middlewares/Third_Party/mbedTLS/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source; ../../../../../../Middlewares/Third_Party/LwIP/src/include; ../../../../../../Middlewares/Third_Party/LwIP/system; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1; ../../../../../../Utilities; ../../../../../../Utilities/Fonts; ../../../../../../Utilities/Log; ../../../BootLoader_OSC/Linker_Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Inc
  OBJCOPY.OOCOutputFile: STM32F769I-Discovery_Azure.bin
  postbuild: cmd /C  "cmd /C ..\..\..\BootLoader_OSC\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "$TARGET_DIR$\$CONFIG_NAME$.bin" 1 bigelf "
  ILINK.IlinkOutputFile: STM32F769I-Discovery.out
  ILINK.IlinkIcfFile: stm32f769xx_flash_for_sfu.icf
  ILINK.IlinkExtraOptions: --config_search ..\..\..\BootLoader_OSC\Linker_Common\EWARM\
  ILINK.IlinkAdditionalLibs: ..\..\..\BootLoader_OSC\2_Images_SBSFU\EWARM\se_interface_appli.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Azure
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters/: hsm_client_riot_STM32Cube.c hsm_client_tpm_STM32Cube.c
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: platform_STM32Cube.c socketio_mbed.c tcpsocketconnection_c_STM32Cube.c threadapi_STM32Cube.c tickcounter_STM32Cube.c tlsio_mbedtls.c
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/samples/STM32Cube_sample/: azure_sha1.c azure_version.c AzureXcubeSample.c
  group Application/User
    ../Src/: main.c stm32f7xx_it.c mbedtls_entropy.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c flash_f7.c net_conf.c
  group Application/Utils
    ../../../../../Misc_Utils/Src/: cloud.c iot_flash_config.c rfu.c
    ../Src/: set_credentials.c
    ../../../../../../Utilities/CLD_utils/http_lib/: http_lib.c
  group Application/Time
    ../../../../../../Utilities/Time/: STM32CubeRTCInterface.c timingSystem.c timedate.c
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Doc
    ../: readme.txt
  group BootLoader
    ../: bootloader_readme.txt
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_hal_eth.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/src/: azure_base64.c base32.c buffer.c connection_string_parser.c consolelogger.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c http_proxy_io.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_token.c string_tokenizer.c strings.c urlencode.c usha.c vector.c ws_url.c xio.c xlogging.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/c-utility/adapters/: agenttime.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-iothub_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/iothub_client/src/: iothub_client_authorization.c iothub_client_core_ll.c iothub_client_diagnostic.c iothub_client_ll.c iothub_client_retry_control.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c iothub_transport_ll_private.c
  group Middlewares/Third_Party/azure-iot-sdk-c/parson
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/deps/parson/: parson.c
  group Middlewares/Third_Party/azure-iot-sdk-c/serializer
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
  group Middlewares/Third_Party/azure-iot-sdk-c/umqtt
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/src/: iothub_auth_client.c iothub_security_factory.c prov_auth_client.c prov_device_ll_client.c prov_security_factory.c prov_transport_mqtt_client.c prov_transport_mqtt_common.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/adapters
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/adapters/: hsm_client_data.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/DICE
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/DICE/: DiceSha256.c
  group Middlewares/Third_Party/azure-iot-sdk-c/c-provisioning_client/RIoT
    ../../../../../../Middlewares/Third_Party/azure-iot-sdk-c/provisioning_client/deps/RIoT/Emulator/RIoT/RIoTCrypt/: RiotAes128.c RiotBase64.c RiotCrypt.c RiotDerEnc.c RiotEcc.c RiotHmac.c RiotKdf.c RiotSha256.c RiotX509Bldr.c
  group Middlewares/Third_Party/MbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group Middlewares/Third_Party/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LwIP/Core/IPV4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c
  group Middlewares/Third_Party/LwIP/System
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/Third_Party/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/ST/STM32_Connect_Library/core
    ../../../../../../Middlewares/ST/STM32_Connect_Library/core/: net_address.c net_core.c net_os.c net_socket.c net_class_extension.c
  group Middlewares/ST/STM32_Connect_Library/services
    ../../../../../../Middlewares/ST/STM32_Connect_Library/services/: net_mbedtls.c net_ping.c net_ip_lwip.c net_ip_ethernetif.c
  group Middlewares/ST/STM32_Connect_Library/netif
    ../../../../../../Middlewares/ST/STM32_Connect_Library/netif/ethernet_if/: net_ethernet_driver.c
