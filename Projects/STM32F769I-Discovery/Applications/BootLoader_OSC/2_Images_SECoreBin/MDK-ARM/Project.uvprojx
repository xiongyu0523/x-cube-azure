# Keil uVision project Project.uvprojx, settings and files
target STM32F769I_Discovery_2_Images_SECoreBin (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: SECoreBin
  BeforeMake: prebuild.bat .
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,MBEDTLS_CONFIG_FILE=<se_mbedtls_config.h>
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/mbedTLS/include;../../../../../../Middlewares/Third_Party/mbedTLS/include/mbedtls;../../../../../../Middlewares/ST/STM32_Secure_Engine/Core;../../../../../../Middlewares/ST/STM32_Secure_Engine/Key;../../2_Images_SBSFU/SBSFU/App;../../Linker_Common/MDK-ARM
  asm include: ROJ_DIR$\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: STM32F769I_Discovery_2_Images_SECoreBin\SECoreBin.sct
  link misc: --entry=SE_CallGate
--diag_suppress L6404W
--diag_suppress L6314W
  group Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: se_key.s data_init.c startup_stm32f769xx.s
  group Middlewares/STM32_Secure_Engine
    ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core/: se_callgate.c se_startup.c se_stack_smuggler_ARM.s se_exception.c se_user_application.c se_bootinfo.c se_fwimg.c se_utils.c
  group Middlewares/Third_Party/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c bignum.c camellia.c cipher.c cipher_wrap.c ecdsa.c ecp.c ecp_curves.c gcm.c hmac_drbg.c md.c md_wrap.c platform.c platform_util.c sha256.c
  group Application/User
    ../Src/: se_low_level.c se_crypto_bootloader.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c
software components: CMSIS:CORE 4.3.0
